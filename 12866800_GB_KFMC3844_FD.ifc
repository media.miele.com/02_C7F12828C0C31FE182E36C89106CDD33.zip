Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: e5b75b62-a8e6-459e-8baa-2f002cda3751, NumberOfSaves: 1]
File name: 0001
Time: 2026-02-09T08:00:04+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12866800_GB_KFMC3844_FD:38384420_GB_12866800_KFMC3844_FD, (2)
In: Default
Type - Material: z_Miele_Design_OBSW, <Unnamed>, z_Miele_Connection_Connection_Modul, z_Miele_Connection_Connection_Water_IN
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 895 mm; Height: 2123 mm; Depth: 608 mm
Pset_BuildingElementProxyCommon - Reference: 38384420_GB_12866800_KFMC3844_FD; sets with these values: 2
